FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://guest-kvm.cfg"
