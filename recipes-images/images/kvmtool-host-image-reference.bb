require kvmtool-host-image.inc
SUMMARY = "Hypervisor Host Image (Reference / No Swap)"
