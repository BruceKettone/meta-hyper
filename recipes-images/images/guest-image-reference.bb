require guest-image.inc
SUMMARY = "Guest Image - Reference (No Swap)"
