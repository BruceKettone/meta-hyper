require qemu-host-image.inc
SUMMARY = "Hypervisor Host Image with QEMU (Reference / No Swap)"
